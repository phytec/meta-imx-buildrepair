SRC_URI_remove = "${FSL_MIRROR}/isp-imx-${PV}.bin;fsl-eula=true"
SRC_URI_append = "https://download.phytec.de/Software/Linux/Yocto/SourceMirror/isp-imx-${PV}_lost_version_1.bin;downloadfilename=isp-imx-${PV}.bin"
